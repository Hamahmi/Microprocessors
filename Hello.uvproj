# Keil uVision project Hello.uvproj, settings and files
target Simulator (MCS-51)
  device: 8XC52 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: HELLO
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: HELLO.C
  group Documentation
    ./: ABSTRACT.TXT
